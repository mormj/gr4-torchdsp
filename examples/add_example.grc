options:
  parameters:
    author: josh
    generate_options: no_gui
    id: untitled
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: nitems
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_0
  id: analog_sig_source
  parameters:
    T: float
    ampl: '1.0'
    frequency: '1000'
    impl: cpu
    offset: '0'
    phase: '0'
    sampling_freq: samp_rate
    showports: 'False'
    waveform: analog.waveform_t.COS
  states: {}
- name: analog_sig_source_0_0
  id: analog_sig_source
  parameters:
    T: float
    ampl: '1.0'
    frequency: '1234'
    impl: cpu
    offset: '0'
    phase: '0'
    sampling_freq: samp_rate
    showports: 'False'
    waveform: analog.waveform_t.COS
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from matplotlib import pyplot as plt
  states: {}
- name: math_add_0
  id: math_add
  parameters:
    T: float
    impl: cpu
    nports: '2'
    showports: 'False'
    vlen: '1'
  states: {state: disabled}
- name: pyqtgraph_pg_time_sink_0
  id: pyqtgraph_pg_time_sink
  parameters:
    T: float
    impl: numpy
    nports: '1'
    showports: 'False'
    size: '1024'
    title: '"hello world"'
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      plt.plot(fg.snk.data())
      plt.show()
    section: main_after_stop
  states: {}
- name: snk
  id: blocks_vector_sink
  parameters:
    T: float
    impl: cpu
    reserve_items: nitems
    showports: 'False'
    vlen: '1'
  states: {}
- name: streamops_head_0
  id: streamops_head
  parameters:
    impl: cpu
    itemsize: '0'
    nitems: nitems
    showports: 'False'
  states: {}
- name: torchdsp_add_0
  id: torchdsp_add
  parameters:
    T: float
    device: cpu_openvino
    impl: triton
    max_batch_size: '256'
    showports: 'False'
    triton_url: localhost:8000
  states: {}

connections:
- [analog_sig_source_0, '0', math_add_0, '0']
- [analog_sig_source_0, '0', torchdsp_add_0, '0']
- [analog_sig_source_0_0, '0', math_add_0, '1']
- [analog_sig_source_0_0, '0', torchdsp_add_0, '1']
- [math_add_0, '0', pyqtgraph_pg_time_sink_0, '0']
- [math_add_0, '0', streamops_head_0, '0']
- [streamops_head_0, '0', snk, '0']
- [torchdsp_add_0, '0', pyqtgraph_pg_time_sink_0, '0']
- [torchdsp_add_0, '0', streamops_head_0, '0']

metadata:
  file_format: 1
